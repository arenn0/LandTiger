# Keil uVision project Blinky.uvproj, settings and files
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky +hex
  c misc: --diag_suppress 550
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Core Code
    ./: core_cm3.c
  group Source Code
    ./: Blinky.c GLCD_LPC1700.c GLCD_TTT.c GLCD_TTT.h TouchPanel.c TouchPanel.h
  group Interrupt
    ./button_EXINT/: IRQ_button.c lib_button.c button.h
    ./led/: led.h funct_led.c lib_led.c
    ./serial/: IRQ_serial.c lib_Serial.c Serial.h
    ./timer/: timer.h funct_timer.c IRQ_timer.c lib_timer.c
